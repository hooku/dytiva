# Keil uVision project M4MP3.uvproj, settings and files
target M4MP3 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: M4MP3
  BeforeMake: C:\Python27\python.exe E:\polone\1\DYTiva\M4MP3\AUTOVER.py
  AfterMake: fromelf --bin --output .\M4MP3.bin .\dbg\M4MP3.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1 _USE_USB USE_DY_PB_2 USE_DY_PB_3 USE_DY_PB_4 USE_DY_PB_FINAL _M4_FREERTOS
  c misc: --c99
  c include: .;C:\ti\TivaWare_C_Series-2.1.0.12573;C:\ti\TivaWare_C_Series-2.1.0.12573\third_party\FreeRTOS\Source\include;C:\ti\TivaWare_C_Series-2.1.0.12573\third_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  asm define: _M4_RTX _M4_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group middleware
    ./: m4_pinmux.h m4_pinmux.c m4_adc.c m4_uart.c m4_temp.c m4_dac.c m4_gpio.c m4_lcd.c m4_pwm.c m4_usbmsc.c m4_time.c m4_cc1101.c m4_sdc.c
  group main
    ./: m4_common.h m4_config.h m4_main.c startup_rvmdk.S m4_app_gui.cpp m4_app_res.h m4_ver.h m4_app_player.c m4_app_demo.c m4_app_phone.c m4_app_sdload.c
  group driver_sdc
    ./: sdc.c
  group driver_fatfs
    ./FatFs/: ff.c ff.h ffconf.h integer.h diskio.h
  group driver_lcd
    ./: uc1701.h uc1701.c hw_uc1701.h
  group driver_codec
    ./: tlv320aic23b.h tlv320aic23b.c sound.c sound.h hw_tlv320aic23b.h
  group driver_fontchip
    ./: gt20l16s1y.h gt20l16s1y.c hw_gt20l16s1y.h
  group driver_temp
    ./: tmp100.h tmp100.c
  group driver_dac
    ./: dac7512.c dac7512.h
  group driver_u8g
    ./u8glib/: u8g_rect.c u8g_circle.c u8g_arm.c u8g_clip.c u8g_com_api.c u8g_com_null.c u8g_dev_uc1701_mini12864.c u8g_font.c u8g_font_data.c u8g_ll_api.c u8g_page.c u8g_pb8v1.c u8g_pb16v1.c u8g_pb.c u8g_state.c u8g_arm.h u8g.h u8g_bitmap.c
  group driver_m2tk
    ./m2tklib/: m2esarmu8g.c m2align.c m2ghdummy.c m2.c m2.h m2dfs.c m2draw.c m2fnarg.c m2gfx.c m2key.c m2navinit.c m2navnext.c m2navroot.c m2navupdn.c m2navutl.c m2obj.c m2usrnext.c m2navfirst.c m2null.c m2rom.c m2elfnfmt.c m2opt.c m2ghu8gicon.c m2ghu8g.h m2ghu8gutl.c m2ellabel.c m2ghu8gbfs.c m2elsb.c m2elstr.c m2gfxutl.c m2elslbase.c m2ellistbase.c m2ellistv.c m2elsubutl.c m2ellistcalc.c m2eh2bs.c m2elu32.c m2navdataup.c m2navdatadn.c m2usrupdn.c m2pin.c m2elxbm.c m2ellisth.c m2elalign.c m2elroot.c
  group library
    C:/ti/TivaWare_C_Series-1.0/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.0.12573/usblib/rvmdk/: usblib.lib
    C:/ti/TivaWare_C_Series-2.1.0.12573/utils/: ustdlib.c
  group rtos_rtx
    ./: RTX_Config.c m4_rtx.c
  group rtos_freertos
    C:/ti/TivaWare_C_Series-2.1.0.12573/third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    C:/ti/TivaWare_C_Series-2.1.0.12573/third_party/FreeRTOS/Source/: list.c queue.c tasks.c
    C:/ti/TivaWare_C_Series-2.1.0.12573/third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./: FreeRTOSConfig.h m4_freertos.c
  group driver_usbmsc
    ./: usbdsdcard.c usb_msc_structs.c usbdsdcard.h usb_msc_structs.h
  group driver_cc1101
    ./cc1101/: CC1100-CC2500.c TI_CC_spi.c
  group driver_accel
    ./tmp/: Accel_App.c bma222drv.h
