# Keil uVision project M4MID.uvproj, settings and files
target M4MID (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: M4MID
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1 USE_M4MID
  c misc: --c99
  c include: .;C:\ti\TivaWare_C_Series-2.1.4.178;C:\ti\TivaWare_C_Series-2.1.4.178\inc;.\fatfs\source
  asm include: C:\ti\TivaWare_C_Series-2.1.4.178\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group app
    ./: m4mid_app_video.cpp m4mid_app_midi.cpp m4mid_app_tfreader.cpp m4mid_common.h m4mid_main.cpp
  group driver
    ./: m4_ili9341.c m4_driverlib.c m4_gt20l16s1y.c m4_usbmidi_host.c m4_sd.c m4_driverlib.h m4_dy_iot_pb_ledkey.c m4_dy_iot_pb_pinmux.c
    C:/ti/TivaWare_C_Series-2.1.4.178/examples/project/: startup_rvmdk.S
  group lib_fatfs
    ./fatfs/source/: ff.c ffconf.h
  group lib_tiva
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.4.178/usblib/rvmdk/: usblib.lib
